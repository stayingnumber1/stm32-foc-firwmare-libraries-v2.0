# Keil uVision project STM32_FOC_PMSM.uvproj, settings and files
target BOOT_FLASH (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BOOT_FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\STM32F10XFWLIB\inc; ..\inc; ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Source
    ../: stm32f10x_it.c
    ../src/: main.c MC_Clarke_Park.c MC_FOC_Drive.c MC_MotorControl_Layer.c MC_Globals.c MC_PID_regulators.c MC_State_Observer_Interface.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_Timebase.c stm32f10x_MCdac.c stm32f10x_svpwm_ics.c MC_Display.c MC_Keys.c stm32f10x_lcd.c
  group Parameters .h files
    ../inc/: STM32F10x_MCconf.h MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_State_Observer_param.h MC_pwm_ics_prm.h
  group Lib
    ./lib/: MC_FOC_Methods_lib.lib MC_State_Observer_lib.lib
  group STM32F10XFWLIB
    ../../STM32F10XFWLIB/src/: stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dbgmcu.c
  group Doc
    ./: readme.txt
